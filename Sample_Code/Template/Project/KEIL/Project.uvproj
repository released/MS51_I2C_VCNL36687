# Keil uVision project Project.uvproj, settings and files
target Master (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\Project;..\VCNL36687
  group Source Group 1
    ../: main.c i2c_master.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c Common.c delay.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group VCNL36687
    ../VCNL36687/: Main_User.c
